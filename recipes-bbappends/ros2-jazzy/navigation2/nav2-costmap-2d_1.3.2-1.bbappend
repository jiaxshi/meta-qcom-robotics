
CXXFLAGS += "-Wno-error=non-virtual-dtor"
CXXFLAGS += "-Wno-error=shadow"
