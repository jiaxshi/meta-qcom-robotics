
CXXFLAGS += "-Wno-error=shadow"
