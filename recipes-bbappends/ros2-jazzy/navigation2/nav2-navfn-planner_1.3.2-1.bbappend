
CXXFLAGS += "-Wno-error=shadow"
CXXFLAGS += "-Wno-error=non-virtual-dtor"
