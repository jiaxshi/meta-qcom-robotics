SRC_URI += "https://github.com/foxglove/ros-foxglove-bridge/commit/9a950ae0fd6e4c87c4ea50b98e6bc3256e2e498f.patch"
SRC_URI[sha256sum] = "791c39599b1d1233af1dccb0efde5c3d039c2b27b3f0f68b7079e37228355704"
