CXXFLAGS += "-Wno-error=deprecated-declarations"
inherit ros_insane_dev_so
