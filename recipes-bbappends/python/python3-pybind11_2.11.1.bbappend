SRC_URI += "https://github.com/pybind/pybind11/pull/4856.patch"

SRC_URI[sha256sum] = "bcc3e39573fb4553d9f8208f95d71c86e55d4d7e92d16e335caec6d6514681d9"
