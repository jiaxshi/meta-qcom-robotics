inherit robotics-package
ROS_EXEC_DEPENDS:remove = "slam-toolbox"

PACKAGES = "qirf-${PN}"