FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:append = " file://0001-modify-CMakeList.txt-to-solve-Werror-problem.patch"


