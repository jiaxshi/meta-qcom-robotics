ROS_BUILD_DEPENDS:remove = "google-benchmark"
ROS_EXPORT_DEPENDS:remove = "google-benchmark"
ROS_EXEC_DEPENDS:remove = "google-benchmark"

ROS_BUILD_DEPENDS:append = "googlebenchmark"
ROS_EXPORT_DEPENDS:append = "googlebenchmark"
ROS_EXEC_DEPENDS:append = "googlebenchmark"
