SRC_URI += "file://0001-fix-cmake-skip-empty-PYBIND11_PYTHON_EXECUTABLE_LAST.patch"
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"